## boards/shields/kyria/Kconfig.shield
```kconfig
# No whitespace after the comma or in the keyboard name!
config SHIELD_KBD
    def_bool $(shields_list_contains,kbd)
```
